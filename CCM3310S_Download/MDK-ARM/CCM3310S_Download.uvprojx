# Keil uVision project CCM3310S_Download.uvprojx, settings and files
target CCM3310S_Download (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: CCM3310S_Download +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_FULL_LL_DRIVER,STM32F103xE,USE_HAL_DRIVER
  c misc: --gnu
  c include: ../Inc;                              ../Drivers/STM32F1xx_HAL_Driver/Inc;                              ../Drivers/CMSIS/Device/ST/STM32F1xx/Include;                              ../Drivers/CMSIS/Include;                              ../mylib;                             ../Middlewares/Third_Party/FreeRTOS/Source/include;                             ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;                             ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;                      ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User
    ../Src/: main.c gpio.c adc.c dma.c freertos.c spi.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_ll_gpio.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_ll_rcc.c stm32f1xx_ll_utils.c stm32f1xx_ll_exti.c stm32f1xx_ll_spi.c stm32f1xx_ll_dma.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_ll_tim.c stm32f1xx_ll_usart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group CMM3310S
    ../mylib/CMM3310S/: ccm3310s_t_loaddown_uart_app.c ccm3310s_t_loaddown_uart_hal.c ccm3310s_t_loaddown_uart_menu.c ccm3310s_uart_hal.c
  group sha1
    ../mylib/sha1/: sha1.c
  group SMx
    ../mylib/SMx/: app_smx_frame.c app_smx_frame_sm2.c app_smx_upload.c SMx_pack.c SMx_upload.c
  group TEA
    ../mylib/tea/: tea.c
  group GB
    ../mylib/GB/: BigLittleEndian.c GB17691.c HJxxx-2019.c
    ../mylib/GB/local/: gb_local_frame_ShangHai.c GBL_real_frame.c ShangHai.c YunJing.c ZhengZhou.c ZhengZhou_3310S.c upload.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
  group MultiTask
    ../mylib/MultiTask/: timTask.c MThread.c
    ../mylib/MultiTask/Task/: TaskNotify.c TaskUpload.c
  group Device
    ../mylib/Device/: dev_max485.c dev_flash.c
software components: CMSIS:CORE 4.3.0
